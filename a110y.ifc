Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-22T16:40:45
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Alternate UI 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Sep 22 16:40:45 2020 * Host: 43-203-2 * Database: C:\Users\A8AC9~1.ZYA\AppData\Local\Temp\{B6DB799D-53BA-47D7-8190-5C4304884BF0}\ifc * Database version: 5507 * Database creation date: Tue Sep 22 16:40:44 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Sep 22 16:40:44 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Sep 22 16:40:44 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
Phase: П

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Данные - ADSK_Титул_Год выпуска: 2019
Идентификация - Название организации: Название организации
Прочее - Адрес проекта: Адрес проекта; Дата утверждения проекта: Дата; Заказчик: Заказчик; Категория: Сведения о проекте; Статус проекта: П

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул_Год выпуска: 2019
Идентификация - Название организации: Название организации
Прочее - Категория: Сведения о проекте; Адрес проекта: Адрес проекта; Дата утверждения проекта: Дата; Заказчик: Заказчик; Статус проекта: П

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Зависимости - Фасад: 0 mm; Базовая отметка: Базовая точка проекта
Идентификация - Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes; Имя типа: Отметка уровня с именем
Размеры - Расчетная высота: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680

# IfcFlowTerminal: А110Y, BIMLIB_Аэратор_Fachmann_А110Y:А110Y:255866
In: Этаж 01
Material: Fachmann_ПВХ_Черный
Pset_ManufacturerTypeInformation - Manufacturer: Fachmann
Pset_DistributionFlowElementCommon - Reference: А110Y
Графика - ДополнительнаяТрубка: yes
Зависимости - Рабочая плоскость: Уровень : Этаж 01; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Отметка по умолчанию: 1219.2 mm
Идентификация - Марка: 24; ADSK_Версия семейства: 1; URL: https://fachmann-rus.ru/; Изготовитель: Fachmann; Имя типа: А110Y; Описание: Аэратор кровельный А 110Y применяется при устройстве «дышащих» кровель и санации кровли. Предназначен для отвода водяных паров из кровельного слоя, что предотвращает образование на кровельном ковре вздутий в холодное время года и образование плесени в теплое время года. Применение аэратора увеличивает срок службы гидроизоляционного ковра.; Производитель_Контакты: Email: all@fachmann-rus.ru; Тел: 8 (800) 511-07-21; Разработчик_Контакты: support@bimlib.pro
Прочее - Категория: Сантехнические приборы; Код типа: BIMLIB_Аэратор_Fachmann_А110Y: А110Y; Семейство: BIMLIB_Аэратор_Fachmann_А110Y: А110Y; Семейство и типоразмер: BIMLIB_Аэратор_Fachmann_А110Y: А110Y; Тип: BIMLIB_Аэратор_Fachmann_А110Y: А110Y; Уровень спецификации: Уровень: Этаж 01; d1: 140 mm; Имя семейства: BIMLIB_Аэратор_Fachmann_А110Y
Размеры - ADSK_Размер_Высота: 470 mm; Объем: 0.00824804 m3; ADSK_Диаметр условный: 110 mm; D_Колпака: 200 mm; D_Юбки: 390 mm
Стадии - Стадия возведения: ПРОЕКТ
Данные - ADSK_URL документации изделия: https://kirov.fachmann-rus.ru/upload/iblock/96d/96d4833a9efde46d2dfba0f754fb91a9.pdf; ADSK_URL страницы изделия: https://kirov.fachmann-rus.ru/catalog/aeratory-deflektory-flugarki/277/; ADSK_Версия Revit: 2017; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: Fachmann; ADSK_Код изделия: 22.23.19.12.1.01.01-0002; ADSK_Количество: 1; ADSK_Марка: A110Y; ADSK_Наименование: Аэратор кровельный A110Y (арт. 01.079); ADSK_Наименование краткое: Аэратор кровельный A110Y
Текст - Fachmann_Артикул: 01.079; Fachmann_СрокСлужбы: не менее 50 лет; Fachmann_ТемператураОкружающейСреды: постоянная - от -40 °С до +80 °С; временная - от -55 °С до +120 °С
